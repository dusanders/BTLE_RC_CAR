<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\HardwareEncryption\HardwareEncryption.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\MspUART.ewp</path>
  </project>
  <batchBuild/>
</workspace>


